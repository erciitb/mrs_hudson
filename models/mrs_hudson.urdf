Commit message: v1.1

File: models/mrs_hudson.urdf (robot description, URDF)
Before this commit: robot mrs_hudson, 4 links, 3 joints
Links:
- added link lidar_link; collision box ; visual box 
Joints:
- added joint lidar_sensor_joint: type fixed, parent , child 
